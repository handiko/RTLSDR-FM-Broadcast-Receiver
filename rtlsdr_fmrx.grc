options:
  parameters:
    author: Handiko
    generate_options: qt_gui
    id: rtlsdr_fmrx
    output_language: python
    title: FM Broadcast Rx
  states: {}

blocks:
- name: af_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: AF Gain (dB)
    start: '-10.0'
    step: '0.1'
    stop: '30.0'
    value: '-3.0'
  states: {}
- name: af_rate
  id: variable
  parameters:
    value: 24e3
  states: {}
- name: cfreq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Tune (MHz)
    start: '88.0'
    step: '0.1'
    stop: '108.0'
    value: '102.2'
  states: {}
- name: ch_lpf
  id: variable_low_pass_filter_taps
  parameters:
    comment: LPF Taps used in the FFT Filter
    cutoff_freq: 150e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: ch_rate
  id: variable
  parameters:
    value: 240e3
  states: {}
- name: rfgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: 'RF Gain (dB):'
    start: '0.0'
    step: '0.1'
    stop: '32.0'
    value: '10.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(ch_rate/af_rate)
    comment: |-
      Quadratute rate = input rate
                                = ch_rate (240 ksps)

      Decimation = input rate / audio rate
                         = ch_rate (240 ksps) / af_rate (24 ksps)
    quad_rate: ch_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(af_rate)
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    comment: |-
      Channel Filter
      Sample rate = samp_rate (2.4 Msps)
    decim: '1'
    taps: ch_lpf
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: rate = af_rate (24 ksps)
    cutoff_freq: 10e3
    decim: '1'
    gain: pow(10,af_gain/10.0)
    samp_rate: af_rate
    type: fir_filter_fff
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: cfreq*1e6
    fftsize: '4096'
    grid: 'True'
    gui_hint: 3,0,1,1
    legend: 'False'
    name: RF Spectrum
    type: complex
    ymax: '-20'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: af_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 4,0,1,1
    legend: 'False'
    name: Audio Spectrum
    type: float
    update_time: '0.01'
    ymax: '-20'
    ymin: '-100'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Interpolation = output rate
                          = ch_rate

      Decimation = input rate
                         = samp_rate
    decim: int(samp_rate)
    interp: int(ch_rate)
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: cfreq*1e6
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', low_pass_filter_0, '0']
- [fft_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rtlsdr_source_0, '0', fft_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
